options:
  parameters:
    generate_options: qt_gui
    id: LoRa_Doppler_Effect
    output_language: python
    title: LoRa
  states: {}

blocks:
- name: SNRdB
  id: variable_qtgui_range
  parameters:
    start: '-15'
    step: '3'
    stop: '0'
    value: '-9'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868.1E6
  states: {}
- name: clk_offset
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '20'
    stop: '200'
    value: '20'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    start: pi/1000
    step: pi/1000
    stop: pi/100
    value: pi/800
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw*4
  states: {}
- name: sf
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '7'
    step: '1'
    stop: '12'
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '0x12'
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pi
    min_freq: '-pi'
    w: loop_bw
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/vinicius/Documentos/Projeto de Iniciação Científica/LoRa Validado/Testes/Arquivo saida
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/vinicius/Documentos/Amostras_Transmitidas
    type: byte
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.intern("TEST: 0")'
    period: '1000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: 1.0+clk_offset*1e-6
    freq_offset: '0'
    minoutbuf: int((2**sf+2)*samp_rate/bw)
    noise_voltage: 10**(-SNRdB/20)
    seed: '0'
    taps: 1.0 + 0.0j
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Embedded Python Block - Geração de Sinal Exponencial Complexo com Frequência Variante no Tempo\"\"\"\n\n    def __init__(self, samp_rate=1.0):\n        \"\"\"Inicializa o bloco com a taxa de amostragem\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Exponencial Complexo com Frequência Variante',  # Nome que aparecerá no GRC\n            in_sig=[np.float32],  # Entrada do tipo float32 (frequência variante no tempo)\n            out_sig=[np.complex64]  # Saída do tipo complex64 (sinal exponencial complexo)\n        )\n        self.samp_rate = samp_rate  # taxa de amostragem\n        self.time_index = 0  # índice de tempo inicial\n\n    def work(self, input_items, output_items):\n        \"\"\"Gera o sinal exponencial complexo com a frequência de entrada\"\"\"\n        freqs = input_items[0]  # Frequências de entrada (variantes no tempo)\n        out = output_items[0]\n\n        # Gera a exponencial complexa\n        for i in range(len(out)):\n            t = self.time_index / self.samp_rate  # Tempo discreto\n            out[i] = np.exp(-1j * 2 * np.pi * freqs[i] * t)  # exp(j 2pi f t)\n            self.time_index += 1\n\n        return len(out)\n\n"
    samp_rate: 1E6
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import time  # Importa o módulo time, que fornece várias funções relacionadas ao tempo.\nimport numpy as np  # Importa o módulo NumPy, utilizado para operações matemáticas e de arrays.\nfrom gnuradio import gr  # Importa o módulo GNU Radio, que é usado para processamento de sinal em tempo real.\n\n# Define uma classe GeradorSenoide que herda de gr.sync_block\nclass GeradorSenoide(gr.sync_block):\n    def __init__(self, taxa_amostragem=1.0e6):\n        # Inicializa o bloco sincronizado com um nome e define que não há entradas (in_sig=None)\n        # e que a saída é um array de números complexos (out_sig=[np.complex64]).\n        gr.sync_block.__init__(\n            self,\n            name='Frequência Doppler',  # Nome do bloco\n            in_sig=None,  # Não há sinal de entrada\n            out_sig=[np.complex64],  # Define a saída como números complexos\n        )\n        self.taxa_amostragem = taxa_amostragem  # Define a taxa de amostragem em Hz\n        self.inicio_tempo = time.time()  # Salva o tempo de início do bloco\n        self.frequencia_doppler = 0  # Inicializa a frequência Doppler com um valor padrão de 1.0 Hz\n\n    # Função para calcular a frequência Doppler com base no tempo atual\n    def calcular_frequencia_doppler(self, tempo_atual):\n        # Retorna a frequência Doppler como uma função senoidal do tempo\n        return 21948.57 * np.sin(0.001 * tempo_atual) / np.sqrt(2.18 - (2.172 * np.cos(0.001 * tempo_atual))) # Variação periódica da frequência\n\n    # Função principal do bloco que é chamada a cada iteração do fluxo de dados\n    def work(self, input_items, output_items):\n        tempo_atual = time.time() - self.inicio_tempo  # Calcula o tempo decorrido desde o início do bloco\n        \n        # Calcula a frequência Doppler atual com base no tempo decorrido\n        self.frequencia_doppler = self.calcular_frequencia_doppler(tempo_atual)\n        \n        # Cria um vetor de tempos t baseado no número de amostras no buffer de saída\n        t = np.arange(len(output_items[0])) / self.taxa_amostragem\n        \n        # Calcula a fase do sinal para cada amostra usando a frequência Doppler\n        fase = 2 * np.pi * self.frequencia_doppler * t\n        \n        # Gera a parte real do sinal senoidal\n        parte_real = np.cos(fase)\n        # Gera a parte imaginária do sinal senoidal\n        parte_imaginaria = np.sin(fase)\n        \n        # Combina a parte real e imaginária para formar um sinal complexo\n        output_items[0][:] = parte_real + 1j * parte_imaginaria\n        \n        return len(output_items[0])  # Retorna o número de amostras processadas\n\n# Bloco de código que executa se o script for rodado diretamente\nif __name__ == '__main__':\n    from gnuradio import blocks  # Importa módulos adicionais do GNU Radio\n    from gnuradio import qtgui  # Importa módulo para visualização de dados com Qt\n    from PyQt5 import Qt  # Importa PyQt5 para interface gráfica\n    import sys  # Importa sys para manipulação de argumentos e sistema\n\n    # Cria um fluxo de dados GNU Radio\n    tb = gr.top_block()\n\n    # Configura os blocos\n    taxa_amostragem = 1.0e6  # Define a taxa de amostragem\n\n    # Instancia o bloco GeradorSenoide com a taxa de amostragem definida\n    bloco_senoide = GeradorSenoide(taxa_amostragem=taxa_amostragem)\n    # Cria um bloco de visualização de sinal no tempo para dados complexos\n    qt_sink = qtgui.time_sink_c(1024, taxa_amostragem, \"Senoide\")\n\n    # Conecta o bloco GeradorSenoide à visualização qt_sink\n    tb.connect(bloco_senoide, qt_sink)\n\n    # Configura a visualização do eixo Y na interface gráfica\n    qt_sink.set_y_axis(-1, 1)\n    qt_sink.set_x_axis_unit(\"s\")  # Define a unidade do eixo X como segundos\n    qt_sink.set_y_axis_unit(\"Amplitude\")  # Define a unidade do eixo Y como amplitude\n\n    # Inicia o fluxo de dados GNU Radio\n    tb.start()\n\n    # Cria uma aplicação Qt\n    app = Qt.QApplication(sys.argv)\n    qtgui_util = qtgui.util()  # Cria uma instância de utilitário do QtGUI\n    qtgui_util.run()  # Executa a interface gráfica Qt\n\n"
    taxa_amostragem: 1E6
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass packet_counter(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"Contador de Pacotes\",\n            in_sig=None,\n            out_sig=[np.uint8])  # Saída como número de pacotes transmitidos\n\n        self.packet_count = 0\n        self.valid_packet_count = 0  # Contador de pacotes validados\n        self.max_packets = 700  # Limite total de pacotes a serem transmitidos\n        self.message_port_register_in(pmt.intern(\"in\"))  # Porta de entrada tipo char\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        # Abre o arquivo para armazenar o resultado\n        self.file = open(\"/home/vinicius/Documentos/Amostras_Transmitidas.txt\", \"w\")\n\n    def handle_msg(self, msg):\n        # Incrementa o contador total de pacotes\n        self.packet_count += 1\n\n        # Converte a mensagem para string\n        msg_str = pmt.symbol_to_string(msg)\n        \n        # Verifica se a mensagem começa com \"TEST: \"\n        if msg_str.startswith(\"TEST: \"):\n            self.valid_packet_count += 1\n        \n        # Verifica se atingiu o número máximo de pacotes\n        if self.packet_count >= self.max_packets:\n            print(\"Limite de pacotes atingido. Parando a execução.\")\n            self.stop()  # Para a execução quando o limite é atingido\n\n        # Atualiza o arquivo após cada mensagem\n        self.file.seek(0)  # Move o cursor para o início do arquivo\n        self.file.write(f\"Total de mensagens transmitidas: {self.packet_count}\\n\")\n        self.file.write(f\"Total de mensagens válidas transmitidas: {self.valid_packet_count}\\n\")\n        self.file.truncate()  # Remove qualquer dado remanescente do arquivo\n\n    def work(self, input_items, output_items):\n        # A saída é o número total de pacotes válidos transmitidos\n        output_items[0][:] = [self.valid_packet_count]\n        return len(output_items[0])\n\n    def stop(self):\n        # Escreve o total de pacotes transmitidos no final do arquivo\n        if self.packet_count < self.max_packets:  # Para garantir que não sobrescreva antes de parar\n            self.file.seek(0)\n            self.file.write(f\"Total de mensagens transmitidas: {self.packet_count}\\n\")\n            self.file.write(f\"Total de mensagens válidas transmitidas: {self.valid_packet_count}\\n\")\n            self.file.truncate()  # Remove qualquer dado remanescente do arquivo\n        self.file.close()  # Fecha o arquivo ao final\n        return gr.sync_block.stop(self)\n\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '2'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    minoutbuf: '10000000'
    preamb_len: preamb_len
    samp_rate: int(samp_rate)
    sf: sf
    sync_words: sync_word
  states: {}
- name: lora_sdr_payload_id_inc_0
  id: lora_sdr_payload_id_inc
  parameters:
    separator: ':'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'True'
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', epy_block_0, '0']
- [blocks_message_strobe_0_0, strobe, lora_sdr_payload_id_inc_0, msg_in]
- [blocks_message_strobe_0_0, strobe, lora_sdr_whitening_0, msg]
- [blocks_multiply_xx_0, '0', analog_pll_freqdet_cf_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0, '0', lora_sdr_frame_sync_0, '0']
- [blocks_multiply_xx_1, '0', lora_sdr_frame_sync_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_xx_0, '0']
- [epy_block_0, '0', blocks_multiply_xx_1, '0']
- [epy_block_1, '0', blocks_multiply_xx_0, '1']
- [epy_block_2, '0', blocks_file_sink_1, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, '0', blocks_file_sink_0, '0']
- [lora_sdr_crc_verif_0, msg, epy_block_2, in]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_throttle_0, '0']
- [lora_sdr_payload_id_inc_0, msg_out, blocks_message_strobe_0_0, set_msg]
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
